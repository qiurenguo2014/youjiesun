# Keil uVision project project.uvproj, settings and files
target STM3210E-FREERTOS-BOOT (ARM-ADS)
  device: STM32F103VE STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: hex +hex
  AfterMake: fromelf --bin --output .\Firmware\project.bin .\OBJ\hex.axf
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F10X_HD
  c include: ..\Libraries;..\Libraries\inc;..\FreeRTOS\include;..\FreeRTOS\portable;.\User;..\FreeRTOS;.\code\emWin\Include
  library: MicroLIB
  memory RVCT4: ROM 0x8002000 size 0x7e000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group App
    ./code/: main.c
    ./code/App/: flashdata.c SIGOP.C pid_temp.c commun.c
  group Drv
    ./code/Drv/t6963/: t6963.c
    ./code/Drv/fm31256/: fm31256.c
    ./code/Drv/tda7396/: tda7396.c
  group Bsp
    ./code/Bsp/: My_InitTask.c bsp_usart.c bsp_i2c.c bsp_relay.c bsp_key.c bsp_systick.c bsp_flash.c bsp_pwm.c bsp_dac.c
    ./code/: stm32f10x_it.c
  group gui
    ./code/gui/: MainWindowDLG.c TestWindowDLG.c historydataWindowDLG.c
    ./code/gui/font/: weiruanyahei20.c kaiti16.c
  group emwin
    ./code/emWin/Sample/DisplayDriver/: GUIDRV_Template.c
    ./code/emWin/Sample/LCDConf/GUIDRV_Lin/Generic/: LCDConf.c
    ./code/emWin/Lib/: GUI_CM3.lib
    ./code/emWin/Sample/GUI_X/: GUI_X_Ex.c
    ./code/emWin/Sample/Config/: GUIConf.c
  group Libraries
    ../Libraries/: system_stm32f10x.c
    ../Libraries/src/: misc.c stm32f10x_gpio.c stm32f10x_flash.c stm32f10x_rcc.c stm32f10x_usart.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_exti.c stm32f10x_i2c.c stm32f10x_dac.c stm32f10x_dma.c
  group Startup
    ../Startup/: startup_stm32f10x_hd.s
    ../Libraries/: core_cm3.c
  group shell
    E:/MyFunc/Shell/: shell.c
    ./code/App/: shell_port.c
  group Doc
    ../: readme.txt
